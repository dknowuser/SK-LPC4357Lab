# Keil uVision project Test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC4357 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
