# Keil uVision project Hid_usb.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC4357 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Hid_usb
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1
  c define: CORE_M0 LPC43XX_CORE_M0APP
  c include: .\Dependence;.\Dependence\config_43xx_m0app;.\Dependence\config_43xx_m0sub
  memory RVCT4: ROM 0x1b000000 size 0x40000
  memory RVCT9: RAM 0x10080000 size 0x8000
  group Source Group 1
    ./: startup_LPC43xx.s hid_desc.c hid_generic.c hid_main.c sysinit.c
  group lib
    ./Dependence/lib/: lib_lpc_chip_43xx_m0.lib lib_lpc_board_keil_mcb_4357_m0.lib
