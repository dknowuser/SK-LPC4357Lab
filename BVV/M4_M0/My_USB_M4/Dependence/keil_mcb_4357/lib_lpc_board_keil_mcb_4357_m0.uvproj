# Keil uVision project lib_lpc_board_keil_mcb_4357_m0.uvproj, settings and files
target keil_mcb_4357 (ARM-ADS)
  device: LPC4357 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lib_lpc_board_keil_mcb_4357_m0 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\board_common;..\..\..\lpc_chip\chip_18xx_43xx;..\..\..\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\..\lpc_chip\chip_common;.\
  scatter file: .\keil_output\core_m4\lib_lpc_board_keil_mcb_4357.sct
  group src
    ./: board.c
    ../../board_common/: lpc_phy_dp83848.c mem_tests.c uda1380.c
