# Keil uVision project M4_Start.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: M4_Start
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  c define: CORE_M4
  c include: .\Dependence\chip_18xx_43xx\config_43xx;.\Dependence\chip_18xx_43xx;.\Dependence\chip_common;.\Dependence\board_common;.\Dependence\keil_mcb_4357;.\Dependence
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: blinky_m4.c sysinit.c keil_startup_lpc18xx43xx.s
    ./Dependence/: ipc_example.c m0_img_ldr.c ipc_msg.c
  group lib
    ./Dependence/lib/: lib_lpc_chip_43xx.lib lib_lpc_board_keil_mcb_4357.lib
